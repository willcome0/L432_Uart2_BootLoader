<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\L432_Uart2_BootLoader.ewp</path>
  </project>
  <batchBuild />
</workspace>
